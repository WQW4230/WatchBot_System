# Keil uVision project STM32_IR.uvprojx, settings and files
target default (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: MPU6050
  c misc: --no-multibyte-chars
  c include: .\std_periph_driver\inc;.\user;.\pal;.\pal\modules\eMPL;.\pal\modules\font;.\pal\modules;.\OLED;.\Hardware_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c system_stm32f10x.c stm32f10x_it.h stm32f10x_it.c remote_nec_driver.c remote_nec_driver.h menu.c menu.h GuessNum.c GuessNum.h GuessMine.c GuessMine.h Contact.c Contact.h GreedySnake.c GreedySnake.h App_Timer.c App_Timer.h LED_Blink.c LED_Blink.h arm_control.c arm_control.h serov_driver.c serov_driver.h ps2_ADC_DMA.c ps2_ADC_DMA.h rtc_driver.c rtc_driver.h Alarm.c Alarm.h Ps2_Key.c Ps2_Key.h usart_frame_handler.c usart_frame_handler.h STM32_slave.c STM32_slave.h
  group startup
    ./startup/: startup_stm32f10x_md.s
  group std_periph_driver
    ./std_periph_driver/inc/: misc.h stm32f10x.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ./std_periph_driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group OLED
    ./OLED/: OLED.c OLED.h OLED_Data.c OLED_Data.h
  group Hardware_Driver
    ./Hardware_Driver/: Active_Buzzer.c Active_Buzzer.h
